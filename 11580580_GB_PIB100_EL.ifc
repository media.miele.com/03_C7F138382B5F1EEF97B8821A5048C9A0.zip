Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 89a579f8-a0f0-448e-8d5f-e2998ecb78a6, NumberOfSaves: 1]
File name: 0001
Time: 2024-08-15T10:44:27+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11580580_GB_PIB100_EL:53100012_GB_11580580_PIB100_EL, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom, z_Miele_Connection_Dampf, z_Miele_Design_BRWS, z_Miele_Design_Cast, z_Miele_Design_CLST, SAN Plastic, z_Miele_Connection_Electric, <Unnamed>
Type - Pset_ProductRequirements - Category: Specialty Equipment
Classification: E1010620 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 53100012_GB_11580580_PIB100_EL; sets with these values: 2

# IfcDistributionPort, Port_355176_1
Description: Flow; FlowDirection: SOURCEANDSINK
